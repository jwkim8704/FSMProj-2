<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\jw-20170907-1.ewp</path>
  </project>
  <batchBuild />
</workspace>
